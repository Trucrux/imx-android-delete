# IAR project sai_low_power_audio.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMX8MP8_M7 NXP MIMX8MP8_M7
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: DEBUG; CPU_MIMX8ML8DVNLZ; SRTM_DEBUG_MESSAGE_FUNC=DbgConsole_Printf; SRTM_DEBUG_VERBOSE_LEVEL=SRTM_DEBUG_VERBOSE_WARN; SERIAL_PORT_TYPE_UART=1; FSL_RTOS_FREE_RTOS
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ../../../../../rtos/freertos/freertos_kernel/portable/IAR/ARM_CM4F; ..; ../../..; ../../../../../middleware/multicore/remoteproc; ../../../../../CMSIS/Core/Include; ../../../../../devices; ../../../../../rtos/freertos/freertos_kernel/include; ../../../../../devices/MIMX8ML8/drivers; ../../../../../components/srtm/channels; ../../../../../components/srtm/services; ../../../../../devices/MIMX8ML8; ../../../../../devices/MIMX8ML8/utilities/str; ../../../../../devices/MIMX8ML8/utilities/debug_console; ../../../../../components/uart; ../../../../../components/serial_manager; ../../../../../components/lists; ../../../../../components/srtm/include; ../../../../../components/srtm/srtm; ../../../../../components/srtm/port; ../../../../../middleware/multicore/rpmsg_lite/lib/include/platform/imx8mp_m7; ../../../../../middleware/multicore/rpmsg_lite/lib/include; ../../../../../devices/MIMX8ML8/utilities
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; NO_CRP; __STARTUP_INITIALIZE_NONCACHEDATA
  AARM.AUserIncludes: ..; ../../..
  OBJCOPY.OOCOutputFile: sai_low_power_audio.bin
  ILINK.IlinkOutputFile: sai_low_power_audio.out
  ILINK.IlinkIcfFile: MIMX8ML8xxxxx_cm7_lpa_ram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MIMX8ML8DVNLZ; SRTM_DEBUG_MESSAGE_FUNC=DbgConsole_Printf; SRTM_DEBUG_VERBOSE_LEVEL=SRTM_DEBUG_VERBOSE_WARN; SERIAL_PORT_TYPE_UART=1; FSL_RTOS_FREE_RTOS
  ICCARM.CCIncludePath2: ../../../../../rtos/freertos/freertos_kernel/portable/IAR/ARM_CM4F; ..; ../../..; ../../../../../middleware/multicore/remoteproc; ../../../../../CMSIS/Include; ../../../../../devices; ../../../../../rtos/freertos/freertos_kernel/include; ../../../../../devices/MIMX8ML8/drivers; ../../../../../components/srtm/channels; ../../../../../components/srtm/services; ../../../../../devices/MIMX8ML8; ../../../../../devices/MIMX8ML8/utilities/str; ../../../../../devices/MIMX8ML8/utilities/debug_console; ../../../../../components/uart; ../../../../../components/serial_manager; ../../../../../components/lists; ../../../../../components/srtm/include; ../../../../../components/srtm/srtm; ../../../../../middleware/multicore/rpmsg_lite/lib/include/platform/imx8mp_m7; ../../../../../middleware/multicore/rpmsg_lite/lib/include; ../../../../../devices/MIMX8ML8/utilities
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG; NO_CRP; __STARTUP_INITIALIZE_NONCACHEDATA
  group board
    ../: board.c board.h clock_config.c clock_config.h ddrc.h dram.h fsl_iomuxc.h lpa_power_management.c lpa_power_management.h pin_mux.c pin_mux.h
  group CMSIS
    ../../../../../CMSIS/Include/: arm_common_tables.h arm_const_structs.h arm_math.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_cm7.h mpu_armv7.h
  group component/lists
    ../../../../../components/lists/: fsl_component_generic_list.c fsl_component_generic_list.h
  group component/serial_manager
    ../../../../../components/serial_manager/: fsl_component_serial_manager.c fsl_component_serial_manager.h fsl_component_serial_port_internal.h fsl_component_serial_port_uart.c fsl_component_serial_port_uart.h
  group component/uart
    ../../../../../components/uart/: fsl_adapter_iuart.c fsl_adapter_uart.h
  group device
    ../../../../../devices/MIMX8ML8/: fsl_device_registers.h MIMX8ML8_cm7.h MIMX8ML8_cm7_features.h system_MIMX8ML8_cm7.c system_MIMX8ML8_cm7.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../devices/MIMX8ML8/drivers/: fsl_audiomix.c fsl_audiomix.h fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_gpc.c fsl_gpc.h fsl_gpio.c fsl_gpio.h fsl_gpt.c fsl_gpt.h fsl_i2c.c fsl_i2c.h fsl_memory.h fsl_mu.c fsl_mu.h fsl_rdc.c fsl_rdc.h fsl_sai.c fsl_sai.h fsl_sai_sdma.c fsl_sai_sdma.h fsl_sdma.c fsl_sdma.h fsl_sdma_script.h fsl_sema4.c fsl_sema4.h fsl_uart.c fsl_uart.h
  group freertos/freertos_kernel
    ../../../../../rtos/freertos/freertos_kernel/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group freertos/freertos_kernel/include
    ../../../../../rtos/freertos/freertos_kernel/include/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h freertos_tasks_c_additions.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stream_buffer.h task.h timers.h
  group freertos/freertos_kernel/portable
    ../../../../../rtos/freertos/freertos_kernel/portable/: readme.txt
  group freertos/freertos_kernel/portable/IAR/ARM_CM4F
    ../../../../../rtos/freertos/freertos_kernel/portable/IAR/ARM_CM4F/: port.c portasm.s portmacro.h
  group freertos/freertos_kernel/portable/MemMang
    ../../../../../rtos/freertos/freertos_kernel/portable/MemMang/: heap_4.c ReadMe.url
  group remoteproc
    ../: remoteproc.h rsc_table.c rsc_table.h
  group rpmsg_lite
    ../../../../../middleware/multicore/rpmsg_lite/lib/common/: llist.c
    ../../../../../middleware/multicore/rpmsg_lite/lib/include/: llist.h rpmsg_compiler.h rpmsg_default_config.h rpmsg_lite.h rpmsg_ns.h virtio_ring.h virtqueue.h
    ../../../../../middleware/multicore/rpmsg_lite/lib/rpmsg_lite/: rpmsg_lite.c rpmsg_ns.c
    ../../../../../middleware/multicore/rpmsg_lite/lib/virtio/: virtqueue.c
  group rpmsg_lite/env/freertos
    ../../../../../middleware/multicore/rpmsg_lite/lib/include/: rpmsg_env.h rpmsg_queue.h
    ../../../../../middleware/multicore/rpmsg_lite/lib/rpmsg_lite/porting/environment/: rpmsg_env_freertos.c
    ../../../../../middleware/multicore/rpmsg_lite/lib/rpmsg_lite/: rpmsg_queue.c
  group rpmsg_lite/porting
    ../../../../../middleware/multicore/rpmsg_lite/lib/rpmsg_lite/porting/platform/imx8mp_m7/: rpmsg_platform.c
    ../../../../../middleware/multicore/rpmsg_lite/lib/include/platform/imx8mp_m7/: rpmsg_platform.h
  group source
    ../: app_srtm.c app_srtm.h FreeRTOSConfig.h lpm.c lpm.h rpmsg_config.h sai_low_power_audio.c sai_low_power_audio.h
  group srtm/channels
    ../../../../../components/srtm/channels/: srtm_rpmsg_endpoint.c srtm_rpmsg_endpoint.h
  group srtm/include
    ../../../../../components/srtm/include/: srtm_channel.h srtm_defs.h srtm_dispatcher.h srtm_message.h srtm_peercore.h srtm_service.h
  group srtm/port
    ../../../../../components/srtm/port/: srtm_heap_freertos.c srtm_message_pool.c srtm_mutex_freertos.c srtm_sem_freertos.c
  group srtm/services
    ../../../../../components/srtm/services/: srtm_audio_service.c srtm_audio_service.h srtm_i2c_service.c srtm_i2c_service.h srtm_sai_sdma_adapter.c srtm_sai_sdma_adapter.h
  group srtm/srtm
    ../../../../../components/srtm/srtm/: srtm_channel.c srtm_channel_struct.h srtm_dispatcher.c srtm_dispatcher_struct.h srtm_heap.h srtm_list.h srtm_message.c srtm_message_pool.h srtm_message_struct.h srtm_mutex.h srtm_peercore.c srtm_peercore_struct.h srtm_sem.h srtm_service.c srtm_service_struct.h
  group startup
    ../../../../../devices/MIMX8ML8/iar/: startup_MIMX8ML8_cm7.s
  group utilities
    ../../../../../devices/MIMX8ML8/utilities/: fsl_assert.c
    ../../../../../devices/MIMX8ML8/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../../../devices/MIMX8ML8/utilities/str/: fsl_str.c fsl_str.h
